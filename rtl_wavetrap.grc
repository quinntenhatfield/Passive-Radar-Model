options:
  parameters:
    author: Muad'Dib
    generate_options: qt_gui
    id: rtl_wavetrap
    output_language: python
    title: WAVETRAP PUSH-BUTTON RF RECORDER
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 102.9e6
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to IQ recording
      and adds timestamp and the 
      'note' variable to the filename
    value: rootdir+record_file_path+note+"_"+str(int(center_freq))+"Hz_"+str(int(gui_samp_rate))+"sps_"+str(gui_gain)+"dB_"
  states: {}
- name: gui_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: RX Gain
    start: '0'
    step: '1'
    stop: '49.6'
    value: '10.0'
  states: {}
- name: gui_samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tabs@0:0,1,1,1
    label: SAMPLE RATE
    labels: '[''1.00MHz'', ''1.54MHz'', ''1.79MHz'', ''1.92MHz'', ''2.00MHz'', ''2.16MHz'', ''2.56MHz'', ''2.88MHz'', ''3.2MHz'', ''5.0MHz'', ''10.0MHz'', ''15.0MHz'',''20MHz'', ''25.0MHz'', ''30.0MHz'', ''35.0MHz'', ''40.0MHz'', ''45.0MHz'', ''50.0MHz'', ''55.0MHz'']'
    num_opts: '0'
    options: '[1000000.0, 1536000.0, 1792000.0, 1920000.0, 2000000.0, 2160000.0, 2560000.0, 2880000.0, 3200000.0, 5000000.0, 10000000.0, 15000000.0,20000000.0, 25000000.0, 30000000.0, 35000000.0, 40000000.0, 45000000.0, 50000000.0, 55000000.0]'
    type: real
    value: '2000000.0'
  states: {}
- name: note
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@0:1,1,1,2
    label: RECORDING NOTE (press enter to update)
    type: string
    value: RECORDING_NOTE
  states: {}
- name: rec_button
  id: variable_qtgui_push_button
  parameters:
    gui_hint: tabs@0:1,3,1,1
    label: RECORD
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"JuliaCode/data/"'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~")+"/")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: str_freq
  id: variable
  parameters:
    value: str(center_freq)
  states: {}
- name: timestamp
  id: variable
  parameters:
    comment: |-
      gets system time and
      applies string formatting
    value: datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H-%M-%S')
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename+"1"+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H-%M-%S'))+".cfile" if rec_button == 1 else "NUL"
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: filename+"2"+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H-%M-%S'))+".cfile" if rec_button == 1 else "NUL"
    type: complex
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: str_freq
  states: {state: disabled}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabs@0:1,0,1,1
    key: freq
    label: Freq
    type: float
    value: str_freq
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: gui_samp_rate
    fc: center_freq
    fftsize: '2048'
    gui_hint: tabs@0:2,0,5,4
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: gui_samp_rate
    fc: center_freq
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: tabs@0:0,3,1,1
    label: '"RED=RECORDING"'
    offColor: green
    onColor: red
    position: '2'
    state: True if rec_button == 1 else False
  states: {}
- name: rf_bw
  id: parameter
  parameters:
    label: RF BANDWITDH
    short_id: b
    type: eng_float
    value: 20e6
  states: {}
- name: rf_freq
  id: parameter
  parameters:
    label: RF FREQUENCY
    short_id: f
    type: eng_float
    value: 1534e6
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF GAIN
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: samp_rate_0
  id: parameter
  parameters:
    label: SAMPLE RATE (choose from [1024000.0, 1536000.0, 1792000.0, 1920000.0, 2000000.0, 2160000.0, 2560000.0, 2880000.0, 3200000.0, 5000000.0, 10000000.0, 15000000.0,20000000.0, 25000000.0, 30000000.0, 35000000.0, 40000000.0, 45000000.0, 50000000.0, 55000000.0])
    short_id: s
    type: eng_float
    value: '1000000'
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: '0'
    biasT: 'False'
    center_freq: center_freq
    center_freq0: center_freq
    center_freq1: center_freq
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '40'
    if_gRdB0: '50'
    if_gRdB1: '50'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gRLNA0: '0'
    rf_gRLNA1: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rf_gRdB0: '0'
    rf_gRdB1: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    rspduo_mode: Dual Tuner (diversity reception)
    sample_rate: samp_rate
    sample_rate_non_single_tuner: 2000e3
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    synchronous_updates: 'False'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,7,4
    label0: Tab 0
    num_tabs: '1'
  states: {}

connections:
- [qtgui_edit_box_msg_0_0, msg, blocks_msgpair_to_var_0, inpair]
- [qtgui_edit_box_msg_0_0, msg, qtgui_freq_sink_x_0, freq]
- [qtgui_freq_sink_x_0, freq, qtgui_edit_box_msg_0_0, val]
- [sdrplay3_rspduo_0, '0', blocks_file_sink_0_0, '0']
- [sdrplay3_rspduo_0, '0', qtgui_freq_sink_x_0, '0']
- [sdrplay3_rspduo_0, '1', blocks_file_sink_0, '0']
- [sdrplay3_rspduo_0, '1', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
